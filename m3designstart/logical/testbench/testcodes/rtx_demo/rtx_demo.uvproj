# Keil uVision project rtx_demo.uvproj, settings and files
target Debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: rtx_demo
  AfterMake: $K\ARM\ARMCC\BIN\fromelf.exe #L -c -d -e -s --output rtx_demo.lst
  AfterMake: $K\ARM\ARMCC\BIN\fromelf.exe #L --bin -o rtx_demo.bin
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: CORTEX_M3
  c include: ..\..\..\..\software\cmsis\CMSIS\Include; ..\..\..\..\software\cmsis\Device\ARM\CM3DS\Include; ..\..\..\..\software\common\retarget
  memory RVCT1: ROM 0x0 size 0x10000
  memory RVCT6: RAM 0x20000000 size 0x10000
  group Startup
    ../../../../software/cmsis/Device/ARM/CM3DS/Source/ARM/: startup_CM3DS.s
  group Application
    ./: rtx_demo.c
    ../../../../software/common/retarget/: uart_stdout.c retarget.c
  group System
    ./: RTX_Config.c
    ../../../../software/cmsis/Device/ARM/CM3DS/Source/: system_CM3DS.c
