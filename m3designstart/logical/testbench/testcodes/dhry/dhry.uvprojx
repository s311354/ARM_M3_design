# Keil uVision project dhry.uvprojx, settings and files
target Debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.0.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: dhry
  AfterMake: $K\ARM\ARMCC\BIN\fromelf.exe #L -c -d -e -s --output dhry.lst
  AfterMake: $K\ARM\ARMCC\BIN\fromelf.exe #L --bin -o dhry.bin
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: CORTEX_M3 USE_PRINT ITERATIONS=200 MSC_CLOCK EXPECTED_SYST
  c misc: -Ono_inline --no_inline --no_multifile -Oloopref
  c include: ..\..\..\..\software\cmsis\CMSIS\Include; ..\..\..\..\software\cmsis\Device\ARM\CM3DS\Include; ..\..\..\..\software\common\retarget
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Startup
    ../../../../software/cmsis/Device/ARM/CM3DS/Source/ARM/: startup_CM3DS.s
  group Application
    ../../../../software/common/dhry/: dhry_1.c dhry_2.c
    ../../../../software/common/retarget/: retarget.c uart_stdout.c
  group System
    ../../../../software/cmsis/Device/ARM/CM3DS/Source/: system_CM3DS.c
target mps2 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.0.0
  cpu: as above
  output: dhry
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: CORTEX_M3 USE_PRINT ITERATIONS=200 MSC_CLOCK EXPECTED_SYST FPGA_IMAGE
  c misc: -Ono_inline --no_inline --no_multifile -Oloopref
  c include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
