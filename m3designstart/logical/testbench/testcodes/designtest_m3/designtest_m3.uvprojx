# Keil uVision project designtest_m3.uvprojx, settings and files
target Debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.0.0
  cpu: IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: designtest_m3
  AfterMake: $K\ARM\ARMCC\BIN\fromelf.exe #L -c -d -e -s --output designtest_m3.lst
  AfterMake: $K\ARM\ARMCC\BIN\fromelf.exe #L --bin -o designtest_m3.bin
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: CORTEX_M3
  c include: ..\..\..\..\software\cmsis\CMSIS\Include; ..\..\..\..\software\cmsis\Device\ARM\CM3DS\Include; ..\..\..\..\software\common\retarget
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Startup
    ../../../../software/cmsis/Device/ARM/CM3DS/Source/ARM/: startup_CM3DS.s
  group Application
    ./: designtest_m3.c
    ../../../../software/common/retarget/: retarget.c uart_stdout.c
    ../../../../software/cmsis/Device/ARM/CM3DS/Source/: CM3DS_MPS2_driver.c
  group System
    ../../../../software/cmsis/Device/ARM/CM3DS/Source/: system_CM3DS.c
target mps2 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.0.0
  cpu: as above
  output: dtest_m3
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: CORTEX_M3 FPGA_IMAGE
  c include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
